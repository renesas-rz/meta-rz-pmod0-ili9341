DESCRIPTION = "fb-test add comand interface to the rect program"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-command-line-interface-for-device-selection.patch \
"
